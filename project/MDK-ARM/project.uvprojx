# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./User;./User/VL53L0X/core/inc;./User/VL53L0X/platform/inc;../FreeRTOS/Source/Include;../FreeRTOS/Portable/RVDS/ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User
    ./User/: Work.c Work.h OLED.c OLED.h dht11.h dht11.c PhotoSensor.h PhotoSensor.c Buzzer.h Buzzer.c ESP8266.c ESP8266.h core_json.c core_json.h Peripheral.c Peripheral.h StepMotor.c StepMotor.h Scheduler.h Scheduler.c driver_passive_buzzer.c driver_passive_buzzer.h driver_timer.c driver_timer.h
  group VL53L0X
    ./User/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ./User/VL53L0X/demo/: vl53l0x.c vl53l0x_gen.c
    ./User/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ./User/VL53L0X/core/inc/: vl53l0x_def.h vl53l0x.h vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h vl53l0x_device.h vl53l0x_gen.h vl53l0x_interrupt_threshold_settings.h vl53l0x_tuning.h
    ./User/VL53L0X/platform/inc/: vl53l0x_i2c.h vl53l0x_platform.h vl53l0x_platform_log.h vl53l0x_types.h
  group FreeRTOS/source
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable
    ../FreeRTOS/Portable/MemMang/: heap_4.c
    ../FreeRTOS/Portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS/include
    ../FreeRTOS/Source/Include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.h stream_buffer.h task.h timers.h
software components: CMSIS:CORE 4.3.0
